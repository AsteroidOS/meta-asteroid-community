SUMMARY = "clean-bars unofficial watchface."
HOMEPAGE = "https://github.com/AsteroidOS/unofficial-watchfaces/"
LICENSE = "GPLv2+"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/GPL-2.0-or-later;md5=fed54355545ffd980b814dab4a3b312c"
require unofficial-watchface.inc
