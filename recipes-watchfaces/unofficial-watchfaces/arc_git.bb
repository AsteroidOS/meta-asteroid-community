SUMMARY = "arc unofficial watchface."
HOMEPAGE = "https://github.com/AsteroidOS/unofficial-watchfaces/"
LICENSE = "CLOSED"
require unofficial-watchface.inc
