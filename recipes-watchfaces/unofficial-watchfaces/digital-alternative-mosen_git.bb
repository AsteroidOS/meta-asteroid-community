SUMMARY = "digital-alternative-mosen unofficial watchface."
HOMEPAGE = "https://github.com/AsteroidOS/unofficial-watchfaces/"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/BSD;md5=3775480a712fc46a69647678acb234cb"
require unofficial-watchface.inc
